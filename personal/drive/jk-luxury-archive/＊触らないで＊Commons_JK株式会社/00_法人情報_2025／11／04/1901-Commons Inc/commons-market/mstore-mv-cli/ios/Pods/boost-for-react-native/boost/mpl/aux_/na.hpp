../../../../../../../../../../../../../../.git/annex/objects/3Q/Gq/MD5E-s1740--947619b9f7ea22234f7f9122d78ecd79.hpp/MD5E-s1740--947619b9f7ea22234f7f9122d78ecd79.hpp
../../../../../../../../../../../../../.git/annex/objects/Qw/1v/MD5E-s580--b47f2b112eaa6c9011372c5688556021.hpp/MD5E-s580--b47f2b112eaa6c9011372c5688556021.hpp
../../../../../../../../../../../../../.git/annex/objects/26/78/MD5E-s814--19bdca38f7d4ace1bb45a792d314438c.hpp/MD5E-s814--19bdca38f7d4ace1bb45a792d314438c.hpp
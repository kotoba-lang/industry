../../../../../../../../../../../../../.git/annex/objects/kp/qG/MD5E-s1328--505ed869772d3d4eca3866b219152ea9.hpp/MD5E-s1328--505ed869772d3d4eca3866b219152ea9.hpp
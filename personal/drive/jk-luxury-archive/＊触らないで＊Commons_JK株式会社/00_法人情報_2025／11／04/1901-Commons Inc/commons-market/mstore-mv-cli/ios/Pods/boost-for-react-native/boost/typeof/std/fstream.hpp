../../../../../../../../../../../../../../.git/annex/objects/2q/gq/MD5E-s1105--62378ebf82e43f5f0f66b23dbb1144ed.hpp/MD5E-s1105--62378ebf82e43f5f0f66b23dbb1144ed.hpp
../../../../../../../../../../../../../../.git/annex/objects/VQ/zg/MD5E-s1641--e0167c26344c20b8984bf86c91cb606b.hpp/MD5E-s1641--e0167c26344c20b8984bf86c91cb606b.hpp
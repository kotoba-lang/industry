../../../../../../../../../../../../../.git/annex/objects/v5/VQ/MD5E-s1582--dedc2be13b7d9429c1db25f8371b3d71.hpp/MD5E-s1582--dedc2be13b7d9429c1db25f8371b3d71.hpp
../../../../../../../../../../../../../../../.git/annex/objects/xj/zG/MD5E-s504--a1ca67b82079a764bb3945fa560fad70.hpp/MD5E-s504--a1ca67b82079a764bb3945fa560fad70.hpp
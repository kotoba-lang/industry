../../../../../../../../../../../../../../.git/annex/objects/Gg/W2/MD5E-s1768--a24feddadcee493b08e885332454bc56.hpp/MD5E-s1768--a24feddadcee493b08e885332454bc56.hpp
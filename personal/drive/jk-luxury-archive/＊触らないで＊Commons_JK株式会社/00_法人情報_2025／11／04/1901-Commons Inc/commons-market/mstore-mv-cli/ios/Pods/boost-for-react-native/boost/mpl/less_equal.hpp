../../../../../../../../../../../../../.git/annex/objects/w0/4Z/MD5E-s557--20ca5d240f8cd9e477769d7a23852584.hpp/MD5E-s557--20ca5d240f8cd9e477769d7a23852584.hpp
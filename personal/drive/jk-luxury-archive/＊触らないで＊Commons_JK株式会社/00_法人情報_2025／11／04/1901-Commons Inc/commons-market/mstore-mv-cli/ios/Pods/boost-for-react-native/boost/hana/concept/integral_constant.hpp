../../../../../../../../../../../../../../.git/annex/objects/gq/v6/MD5E-s1207--b99bb27428dfd0ad27551cce2de8ac5f.hpp/MD5E-s1207--b99bb27428dfd0ad27551cce2de8ac5f.hpp
../../../../../../../../../../../../../../.git/annex/objects/1q/Qw/MD5E-s1192--b574e27de8a3302be40e1531c5515053.hpp/MD5E-s1192--b574e27de8a3302be40e1531c5515053.hpp
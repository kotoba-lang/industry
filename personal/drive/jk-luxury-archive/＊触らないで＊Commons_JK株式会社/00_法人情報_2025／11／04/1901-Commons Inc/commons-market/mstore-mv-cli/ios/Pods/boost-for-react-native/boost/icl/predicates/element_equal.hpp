../../../../../../../../../../../../../../.git/annex/objects/7X/1z/MD5E-s1107--72df7d61ae03f8787c05b25a0415b9ce.hpp/MD5E-s1107--72df7d61ae03f8787c05b25a0415b9ce.hpp
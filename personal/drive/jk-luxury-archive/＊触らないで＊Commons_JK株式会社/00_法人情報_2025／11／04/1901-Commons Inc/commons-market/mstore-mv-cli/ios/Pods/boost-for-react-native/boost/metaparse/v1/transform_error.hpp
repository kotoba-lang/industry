../../../../../../../../../../../../../../.git/annex/objects/43/KG/MD5E-s1001--33f7495c13a86ef2723755828c304cb6.hpp/MD5E-s1001--33f7495c13a86ef2723755828c304cb6.hpp
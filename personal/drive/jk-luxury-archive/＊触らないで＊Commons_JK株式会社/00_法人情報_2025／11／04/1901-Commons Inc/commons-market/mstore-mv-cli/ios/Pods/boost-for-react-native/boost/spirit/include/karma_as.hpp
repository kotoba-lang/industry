../../../../../../../../../../../../../../.git/annex/objects/6M/q3/MD5E-s678--43dfcd81db2914fd9c89746a55c1ebbf.hpp/MD5E-s678--43dfcd81db2914fd9c89746a55c1ebbf.hpp
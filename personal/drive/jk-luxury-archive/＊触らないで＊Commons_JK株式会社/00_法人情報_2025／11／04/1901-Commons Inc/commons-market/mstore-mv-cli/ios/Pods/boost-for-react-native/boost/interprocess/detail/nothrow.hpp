../../../../../../../../../../../../../../.git/annex/objects/Qw/66/MD5E-s1241--d3671a0f1afbfbd6f8e3f268146964f0.hpp/MD5E-s1241--d3671a0f1afbfbd6f8e3f268146964f0.hpp
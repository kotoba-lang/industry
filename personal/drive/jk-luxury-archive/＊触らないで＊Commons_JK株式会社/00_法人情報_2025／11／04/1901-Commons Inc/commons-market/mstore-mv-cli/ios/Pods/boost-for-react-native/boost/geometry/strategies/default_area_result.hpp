../../../../../../../../../../../../../../.git/annex/objects/Gw/48/MD5E-s1685--010e7f5237487799a7fab44cf4541565.hpp/MD5E-s1685--010e7f5237487799a7fab44cf4541565.hpp
../../../../../../../../../../../../../../.git/annex/objects/Q3/6f/MD5E-s563--3df7c55fafa5abe5a9605e1a5f134809.hpp/MD5E-s563--3df7c55fafa5abe5a9605e1a5f134809.hpp
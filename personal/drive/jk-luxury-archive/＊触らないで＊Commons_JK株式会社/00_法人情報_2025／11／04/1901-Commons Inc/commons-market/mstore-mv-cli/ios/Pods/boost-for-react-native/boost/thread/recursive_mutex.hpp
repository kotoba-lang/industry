../../../../../../../../../../../../../.git/annex/objects/Gz/Wg/MD5E-s1599--c062e7c4c81e6203c966cc9329c983fd.hpp/MD5E-s1599--c062e7c4c81e6203c966cc9329c983fd.hpp
../../../../../../../../../../../../../../.git/annex/objects/q3/6q/MD5E-s1122--ea9942fac1422bc11fb6fef30c494706.hpp/MD5E-s1122--ea9942fac1422bc11fb6fef30c494706.hpp
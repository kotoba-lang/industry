../../../../../../../../../../../../../../.git/annex/objects/ZQ/xX/MD5E-s1682--fdb302a7c01bad446aaff06333af7240.hpp/MD5E-s1682--fdb302a7c01bad446aaff06333af7240.hpp
../../../../../../../../../../../../../../.git/annex/objects/FF/5w/MD5E-s600--b4eb9fcf70738f01147e3416456696fe.hpp/MD5E-s600--b4eb9fcf70738f01147e3416456696fe.hpp
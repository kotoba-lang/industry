../../../../../../../../../../../../.git/annex/objects/6M/MQ/MD5E-s4287--674071c6e91825438c309f48d43cabc3.cpp/MD5E-s4287--674071c6e91825438c309f48d43cabc3.cpp
../../../../../../../../../../../../.git/annex/objects/w6/zX/MD5E-s1925--345530e2fce14bd14a9eeecf6cc8de05.hpp/MD5E-s1925--345530e2fce14bd14a9eeecf6cc8de05.hpp
../../../../../../../../../../../../../.git/annex/objects/Wk/v7/MD5E-s343--46ade22d600d1246134ebdabba084293.cpp/MD5E-s343--46ade22d600d1246134ebdabba084293.cpp
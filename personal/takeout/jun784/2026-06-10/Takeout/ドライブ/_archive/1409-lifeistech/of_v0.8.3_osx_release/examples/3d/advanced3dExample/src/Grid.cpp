../../../../../../../../../../../../../.git/annex/objects/64/gK/MD5E-s243--59cb6c1b1fb1eaa0878bcd9816bc0658.cpp/MD5E-s243--59cb6c1b1fb1eaa0878bcd9816bc0658.cpp
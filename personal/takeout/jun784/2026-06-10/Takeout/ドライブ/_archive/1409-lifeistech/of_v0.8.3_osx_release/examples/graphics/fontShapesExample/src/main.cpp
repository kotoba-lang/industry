../../../../../../../../../../../../../.git/annex/objects/W7/9g/MD5E-s343--4a2fb40bb98523b5543d7063e55326d7.cpp/MD5E-s343--4a2fb40bb98523b5543d7063e55326d7.cpp
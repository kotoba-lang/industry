../../../../../../../../../../../../../.git/annex/objects/58/8M/MD5E-s5051--e6ca9d25ccae0d6bb499704f847eb670.cpp/MD5E-s5051--e6ca9d25ccae0d6bb499704f847eb670.cpp
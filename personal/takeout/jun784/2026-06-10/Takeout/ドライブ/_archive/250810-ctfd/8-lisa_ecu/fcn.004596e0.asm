../../../../../../../../../.git/annex/objects/pz/4k/MD5E-s4932--0d82700984b3c7723e2e95ade6935dc5.asm/MD5E-s4932--0d82700984b3c7723e2e95ade6935dc5.asm
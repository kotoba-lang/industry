../../../../../../../../../../../../../../../../.git/annex/objects/MQ/01/MD5E-s993--6daf11ccbe0dfb80ea04c434c905fd55.hpp/MD5E-s993--6daf11ccbe0dfb80ea04c434c905fd55.hpp
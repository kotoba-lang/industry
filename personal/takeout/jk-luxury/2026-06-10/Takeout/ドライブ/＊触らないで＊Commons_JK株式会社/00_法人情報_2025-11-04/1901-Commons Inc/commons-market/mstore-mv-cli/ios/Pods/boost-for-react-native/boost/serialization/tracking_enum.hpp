../../../../../../../../../../../../../../../../.git/annex/objects/43/61/MD5E-s1270--586e531fcf919cb271992a75609de7ee.hpp/MD5E-s1270--586e531fcf919cb271992a75609de7ee.hpp
../../../../../../../../../../../../../../../../../.git/annex/objects/J6/99/MD5E-s1342--60770a96fc401233bcb83f5fa8eef311.hpp/MD5E-s1342--60770a96fc401233bcb83f5fa8eef311.hpp
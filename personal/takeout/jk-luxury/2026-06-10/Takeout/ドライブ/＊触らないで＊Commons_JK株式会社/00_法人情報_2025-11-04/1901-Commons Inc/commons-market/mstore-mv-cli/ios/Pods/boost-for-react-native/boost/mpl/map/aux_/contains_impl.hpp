../../../../../../../../../../../../../../../../../../.git/annex/objects/6z/6p/MD5E-s1060--8f14781e120c278b196300da27692679.hpp/MD5E-s1060--8f14781e120c278b196300da27692679.hpp
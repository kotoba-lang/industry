../../../../../../../../../../../../../../../../../.git/annex/objects/gw/XG/MD5E-s1296--0d038a85894d2d5deb6fb59be1013b54.hpp/MD5E-s1296--0d038a85894d2d5deb6fb59be1013b54.hpp
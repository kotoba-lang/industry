../../../../../../../../../../../../../../../../.git/annex/objects/mw/qK/MD5E-s592--ec60b1c1c1f29580bb92021ce44814fa.hpp/MD5E-s592--ec60b1c1c1f29580bb92021ce44814fa.hpp
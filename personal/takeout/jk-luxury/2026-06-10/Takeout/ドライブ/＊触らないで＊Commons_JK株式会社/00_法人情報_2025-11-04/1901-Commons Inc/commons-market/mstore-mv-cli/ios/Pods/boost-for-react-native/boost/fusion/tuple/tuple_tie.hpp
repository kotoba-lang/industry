../../../../../../../../../../../../../../../../../.git/annex/objects/Gg/1p/MD5E-s1304--de3a9760f9bea9d12c7691e93832836a.hpp/MD5E-s1304--de3a9760f9bea9d12c7691e93832836a.hpp
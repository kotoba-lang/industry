../../../../../../../../../../../../../../../../../.git/annex/objects/3k/93/MD5E-s1447--f78896075845c2649ca53f05c0ee66cb.hpp/MD5E-s1447--f78896075845c2649ca53f05c0ee66cb.hpp
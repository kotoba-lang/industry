../../../../../../../../../../../../../../../.git/annex/objects/09/WQ/MD5E-s522--246e7320ac2244aecd9edb6d9732d333.hpp/MD5E-s522--246e7320ac2244aecd9edb6d9732d333.hpp
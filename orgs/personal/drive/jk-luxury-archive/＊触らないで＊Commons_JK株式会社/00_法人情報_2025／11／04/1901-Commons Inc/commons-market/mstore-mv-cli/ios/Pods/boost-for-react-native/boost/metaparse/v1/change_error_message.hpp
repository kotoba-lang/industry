../../../../../../../../../../../../../../../.git/annex/objects/45/6g/MD5E-s983--68505b9feb19035a3ba7a2c1048698ca.hpp/MD5E-s983--68505b9feb19035a3ba7a2c1048698ca.hpp
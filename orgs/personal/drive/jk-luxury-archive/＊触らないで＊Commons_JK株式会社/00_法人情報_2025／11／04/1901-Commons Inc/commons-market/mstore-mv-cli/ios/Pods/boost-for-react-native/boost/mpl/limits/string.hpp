../../../../../../../../../../../../../../../.git/annex/objects/g0/vq/MD5E-s644--714e713de93b0da2ac7869b018f0a000.hpp/MD5E-s644--714e713de93b0da2ac7869b018f0a000.hpp
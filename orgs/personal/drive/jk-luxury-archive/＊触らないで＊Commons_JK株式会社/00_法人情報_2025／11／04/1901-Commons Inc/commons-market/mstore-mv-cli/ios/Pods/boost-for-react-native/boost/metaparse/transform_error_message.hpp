../../../../../../../../../../../../../../.git/annex/objects/K8/x6/MD5E-s508--d8ef18349362fd9e69bc7c19c1d5fef6.hpp/MD5E-s508--d8ef18349362fd9e69bc7c19c1d5fef6.hpp
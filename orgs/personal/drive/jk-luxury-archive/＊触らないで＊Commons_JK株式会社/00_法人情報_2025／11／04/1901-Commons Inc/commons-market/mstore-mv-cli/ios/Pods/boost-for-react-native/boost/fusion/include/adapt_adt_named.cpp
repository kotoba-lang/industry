../../../../../../../../../../../../../../../.git/annex/objects/Wv/GK/MD5E-s552--afc97bc237eca0ecc03cf67f5a7f24bb.cpp/MD5E-s552--afc97bc237eca0ecc03cf67f5a7f24bb.cpp
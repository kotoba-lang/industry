../../../../../../../../../../../../../../../.git/annex/objects/fg/3G/MD5E-s1105--a584055910a8b807f7f8a073f7ec5c1a.hpp/MD5E-s1105--a584055910a8b807f7f8a073f7ec5c1a.hpp
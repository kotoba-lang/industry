../../../../../../../../../../../../../../.git/annex/objects/Gj/vq/MD5E-s1696--196013dca5478053341ed534b9dc5eb9.hpp/MD5E-s1696--196013dca5478053341ed534b9dc5eb9.hpp
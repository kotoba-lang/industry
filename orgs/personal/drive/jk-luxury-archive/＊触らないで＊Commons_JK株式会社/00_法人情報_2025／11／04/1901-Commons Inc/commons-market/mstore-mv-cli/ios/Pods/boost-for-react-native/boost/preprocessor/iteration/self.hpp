../../../../../../../../../../../../../../../.git/annex/objects/VQ/p0/MD5E-s839--b138da78d4d1dbfed96abcbb0319183b.hpp/MD5E-s839--b138da78d4d1dbfed96abcbb0319183b.hpp
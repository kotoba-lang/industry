../../../../../../../../../../../../../../.git/annex/objects/49/2w/MD5E-s696--e77b3d30b7df8b3affccb6a3b7cfcfc1.hpp/MD5E-s696--e77b3d30b7df8b3affccb6a3b7cfcfc1.hpp
../../../../../../../../../../../../../../../.git/annex/objects/6K/7Q/MD5E-s580--12f333952e8a65a836cd1941781bf4a0.hpp/MD5E-s580--12f333952e8a65a836cd1941781bf4a0.hpp
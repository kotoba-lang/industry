../../../../../../../../../../../../../../.git/annex/objects/20/41/MD5E-s1003--8b795d2c78c608d477196492c8345467.hpp/MD5E-s1003--8b795d2c78c608d477196492c8345467.hpp
../../../../../../../../../../../../../../../.git/annex/objects/58/x2/MD5E-s1269--e32789821ce8f01bd81ba4a2db3cbbfe.hpp/MD5E-s1269--e32789821ce8f01bd81ba4a2db3cbbfe.hpp
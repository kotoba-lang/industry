../../../../../../../../../../../../../../../.git/annex/objects/X1/9W/MD5E-s599--c0e10d43ff383bb4ddaa16559b98fd2d.hpp/MD5E-s599--c0e10d43ff383bb4ddaa16559b98fd2d.hpp
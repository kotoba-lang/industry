../../../../../../../../../../../../../../../.git/annex/objects/Gw/Qp/MD5E-s669--49afb492404dbcc1b258cf422768311c.hpp/MD5E-s669--49afb492404dbcc1b258cf422768311c.hpp
../../../../../../../../../../../../../../../.git/annex/objects/55/1p/MD5E-s1244--21171e35040d999d448e1056b1fd926f.hpp/MD5E-s1244--21171e35040d999d448e1056b1fd926f.hpp
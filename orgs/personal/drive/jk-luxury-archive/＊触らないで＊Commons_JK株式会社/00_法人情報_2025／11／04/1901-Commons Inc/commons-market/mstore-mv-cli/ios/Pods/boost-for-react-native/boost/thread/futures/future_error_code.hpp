../../../../../../../../../../../../../../../.git/annex/objects/GG/gf/MD5E-s1680--05026d4b820a1116cb7ccd5adf5b7ffa.hpp/MD5E-s1680--05026d4b820a1116cb7ccd5adf5b7ffa.hpp
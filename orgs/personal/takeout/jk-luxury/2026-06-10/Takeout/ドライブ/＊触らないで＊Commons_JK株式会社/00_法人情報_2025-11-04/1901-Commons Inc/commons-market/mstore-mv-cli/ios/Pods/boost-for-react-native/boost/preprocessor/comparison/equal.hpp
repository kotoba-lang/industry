../../../../../../../../../../../../../../../../../../.git/annex/objects/42/v0/MD5E-s1040--ddd058e3ec2319ad7fa3c37e43eab40e.hpp/MD5E-s1040--ddd058e3ec2319ad7fa3c37e43eab40e.hpp
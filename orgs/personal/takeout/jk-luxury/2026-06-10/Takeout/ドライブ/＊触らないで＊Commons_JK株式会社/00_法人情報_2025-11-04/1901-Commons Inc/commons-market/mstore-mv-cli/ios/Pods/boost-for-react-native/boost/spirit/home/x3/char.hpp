../../../../../../../../../../../../../../../../../../../.git/annex/objects/zk/VQ/MD5E-s857--410805614a367018d9991e6b77292ef2.hpp/MD5E-s857--410805614a367018d9991e6b77292ef2.hpp
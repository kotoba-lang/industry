../../../../../../../../../../../../../../../../../../.git/annex/objects/98/ww/MD5E-s1004--6eaf33ce5f353a1ed83957f6896d6682.hpp/MD5E-s1004--6eaf33ce5f353a1ed83957f6896d6682.hpp
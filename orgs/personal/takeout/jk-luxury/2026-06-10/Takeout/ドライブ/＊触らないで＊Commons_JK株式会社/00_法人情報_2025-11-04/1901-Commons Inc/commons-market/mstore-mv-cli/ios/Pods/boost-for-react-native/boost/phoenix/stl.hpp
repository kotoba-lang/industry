../../../../../../../../../../../../../../../../../.git/annex/objects/17/62/MD5E-s598--bdcbed8f0e20b8224be9a023c78effcf.hpp/MD5E-s598--bdcbed8f0e20b8224be9a023c78effcf.hpp
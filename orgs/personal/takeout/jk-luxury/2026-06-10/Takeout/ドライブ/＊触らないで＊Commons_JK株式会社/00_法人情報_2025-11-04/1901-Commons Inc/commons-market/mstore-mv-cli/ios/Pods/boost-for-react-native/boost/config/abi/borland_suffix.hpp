../../../../../../../../../../../../../../../../../../.git/annex/objects/wq/56/MD5E-s292--5bd33e5b8b237a0601f1a6825b6faf4b.hpp/MD5E-s292--5bd33e5b8b237a0601f1a6825b6faf4b.hpp
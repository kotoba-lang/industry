../../../../../../../../../../../../../../.git/annex/objects/xg/18/MD5E-s345--79adb4cf0adc7990b11e711e6b891684.cpp/MD5E-s345--79adb4cf0adc7990b11e711e6b891684.cpp
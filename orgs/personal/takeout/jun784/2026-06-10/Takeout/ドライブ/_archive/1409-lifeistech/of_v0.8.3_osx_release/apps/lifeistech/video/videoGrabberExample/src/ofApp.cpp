../../../../../../../../../../../../../../../.git/annex/objects/MM/8k/MD5E-s2982--872284c04299555645315c646dd65afd.cpp/MD5E-s2982--872284c04299555645315c646dd65afd.cpp
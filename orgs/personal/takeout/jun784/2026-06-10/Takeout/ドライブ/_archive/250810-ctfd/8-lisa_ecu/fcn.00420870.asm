../../../../../../../../../../.git/annex/objects/Pk/f4/MD5E-s28728--994626ab79a1c5fcb745473d1fc52a13.asm/MD5E-s28728--994626ab79a1c5fcb745473d1fc52a13.asm
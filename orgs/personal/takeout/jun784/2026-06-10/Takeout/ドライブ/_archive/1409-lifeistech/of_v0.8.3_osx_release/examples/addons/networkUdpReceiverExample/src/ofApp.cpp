../../../../../../../../../../../../../../.git/annex/objects/mk/mq/MD5E-s2269--6ffb33b27969bf2b88d74625064be95f.cpp/MD5E-s2269--6ffb33b27969bf2b88d74625064be95f.cpp
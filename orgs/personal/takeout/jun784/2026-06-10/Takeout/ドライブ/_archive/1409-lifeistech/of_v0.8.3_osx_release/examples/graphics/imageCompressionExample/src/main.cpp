../../../../../../../../../../../../../../.git/annex/objects/26/gP/MD5E-s343--a0ab86afb98917fa2a96314dd12e4a24.cpp/MD5E-s343--a0ab86afb98917fa2a96314dd12e4a24.cpp
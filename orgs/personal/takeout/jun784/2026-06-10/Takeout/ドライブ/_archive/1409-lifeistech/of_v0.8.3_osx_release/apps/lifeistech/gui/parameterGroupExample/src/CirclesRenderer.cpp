../../../../../../../../../../../../../../../.git/annex/objects/4K/QQ/MD5E-s887--9a584df1522b10aeb55c155c684d5ef6.cpp/MD5E-s887--9a584df1522b10aeb55c155c684d5ef6.cpp
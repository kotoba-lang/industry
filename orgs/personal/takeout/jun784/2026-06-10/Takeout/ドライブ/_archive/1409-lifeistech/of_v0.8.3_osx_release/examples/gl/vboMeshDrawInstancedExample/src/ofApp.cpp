../../../../../../../../../../../../../../.git/annex/objects/01/GZ/MD5E-s5069--75ee55bb61fc02b8180296d3c052b7fd.cpp/MD5E-s5069--75ee55bb61fc02b8180296d3c052b7fd.cpp
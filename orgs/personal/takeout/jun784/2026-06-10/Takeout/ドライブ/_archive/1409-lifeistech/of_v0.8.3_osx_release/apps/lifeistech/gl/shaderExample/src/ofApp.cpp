../../../../../../../../../../../../../../../.git/annex/objects/2w/5X/MD5E-s2620--d1cd3eca25815164b12d8068524dc925.cpp/MD5E-s2620--d1cd3eca25815164b12d8068524dc925.cpp
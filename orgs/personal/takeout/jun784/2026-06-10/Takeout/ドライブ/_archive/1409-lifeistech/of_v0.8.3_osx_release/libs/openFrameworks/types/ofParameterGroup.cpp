../../../../../../../../../../../../../.git/annex/objects/pG/WQ/MD5E-s6117--aaa42e4ee504434e1dd037025c315af1.cpp/MD5E-s6117--aaa42e4ee504434e1dd037025c315af1.cpp
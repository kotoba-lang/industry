../../../../../../../../../../../../../../../../../.git/annex/objects/P5/QG/MD5E-s15417--52d74c3b92a38a24a69951b007269e71.cpp/MD5E-s15417--52d74c3b92a38a24a69951b007269e71.cpp
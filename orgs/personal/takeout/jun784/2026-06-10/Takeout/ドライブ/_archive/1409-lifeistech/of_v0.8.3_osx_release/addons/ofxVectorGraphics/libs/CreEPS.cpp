../../../../../../../../../../../../../.git/annex/objects/W6/gp/MD5E-s62922--f9ae646391070bdfae682f34885dcb12.cpp/MD5E-s62922--f9ae646391070bdfae682f34885dcb12.cpp